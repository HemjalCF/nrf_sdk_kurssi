## test_fw/Kconfig
```kconfig
source "kconfig.zephyr"

config MYFUNCTION
	bool "Enable my function"
	default n
```
